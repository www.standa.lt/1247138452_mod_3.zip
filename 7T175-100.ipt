# Autodesk Inventor part: 7T175-100
## iProperties
Created: 2007-06
Part Number: 7T175-100
Document SubType Name: Modeling
Designer: Darius
Author: Darius
## Feature names
1. Base1
